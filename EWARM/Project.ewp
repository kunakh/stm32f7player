# IAR project Project.ewp, settings and files
configuration STM32F7-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F756xx; USE_HAL_DRIVER; USE_STM32746G_DISCOVERY
  ICCARM.CCIncludePath2: ..\inc; ..\STemWin_Addons; ..\Config; ..\Core\inc; ..\STemWin_Addons; ..\Modules\vnc_server; ..\Utilities\CPU; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\Drivers\BSP\STM32746G-Discovery; ..\Drivers\BSP\Components; ..\Drivers\BSP\Components\Common; ..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc; ..\Middlewares\Third_Party\LwIP\src\include\; ..\Middlewares\Third_Party\LwIP\src\include\ipv4; ..\Middlewares\Third_Party\LwIP\system; ..\Middlewares\Third_Party\LwIP\system\OS; ..\Middlewares\ST\STemWin\inc; ..\Middlewares\Third_Party\FatFs\src; ..\Middlewares\Third_Party\FatFs\src\drivers; ..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\Modules\audio_player\Addons\SpiritDSP_Equalizer; ..\Modules\audio_player\Addons\SpiritDSP_LoudnessControl
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: STM327x6G-EVAL_Demo.out
  ILINK.IlinkIcfFile: stm32f746g.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ffmpeg (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; USE_HAL_DRIVER; USE_STM32746G_DISCO; ARM_MATH_CM7; DATA_IN_ExtSDRAM
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: ..\inc; ..\STemWin_Addons; ..\Config; ..\Core\inc; ..\STemWin_Addons; ..\Modules\vnc_server; ..\Utilities\CPU; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\Drivers\BSP\STM32746G-Discovery; ..\Drivers\BSP\Components; ..\Drivers\BSP\Components\Common; ..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc; ..\Middlewares\Third_Party\LwIP\src\include\; ..\Middlewares\Third_Party\LwIP\src\include\ipv4; ..\Middlewares\Third_Party\LwIP\system; ..\Middlewares\Third_Party\LwIP\system\OS; ..\Middlewares\ST\STemWin\inc; ..\Middlewares\Third_Party\FatFs\src; ..\Middlewares\Third_Party\FatFs\src\drivers; ..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\Modules\audio_player\Addons\SpiritDSP_Equalizer; ..\Modules\audio_player\Addons\SpiritDSP_LoudnessControl; ..\ffmpeg-2.7.2\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f746xx_extmem.icf
  ILINK.IlinkExtraOptions: --diag_suppress Lp019
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: k_bsp.c k_memory.c k_menu.c k_module.c k_rtc.c k_startup.c k_storage.c main.c play.c scale.c stm32f7xx_it.c test.c
  group Application/User/Modules/Audio
    ../Modules/audio_player/: audio_player_app.c audio_player_win.c
  group Application/User/Modules/Audio/Addons
    ../Modules/audio_player/Addons/SpiritDSP_Equalizer/: lib_equalizer_cortex_m4.a
    ../Modules/audio_player/Addons/SpiritDSP_LoudnessControl/: lib_loudness_cortex_m4.a
  group Application/User/Modules/audio_recorder
    ../Modules/audio_recorder/: audio_recorder_app.c audio_recorder_win.c
  group Application/User/Modules/Common
    ../Modules/Common/: audio_if.c
  group Application/User/Modules/games
    ../Modules/games/: games_win.c
  group Application/User/Modules/gardening_control
    ../Modules/gardening_control/: gardening_control_win.c
  group Application/User/Modules/home_alarm
    ../Modules/home_alarme/: home_alarm_win.c
  group Application/User/Modules/sys_info
    ../Modules/settings/: settings_win.c
  group Application/User/Modules/VideoPlayer
    ../Modules/videoplayer/: video_player_win.c
  group Application/User/Modules/vnc_server
    ../Modules/vnc_server/: ethernetif.c vnc_app.c vnc_server_win.c
  group Application/User/Utilities
    ../Utilities/CPU/: cpu_utils.c
  group Drivers/BSP/Component
    ../Drivers/BSP/Components/ft5336/: ft5336.c
    ../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32746G_DISCO
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F4xx_HAL_Drivers
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Lib
    ../Lib/: libavcodec.a libavdevice.a libavfilter.a libavformat.a libavutil.a libswresample.a libswscale.a
  group Middlewares/FatFs/Core
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c usbh_diskio.c
  group Middlewares/FatFs/Options
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3_MPU/: port.c portmacro.h
  group Middlewares/LwIP/Api
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/Core
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group Middlewares/LwIP/Core/IPv4
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Middlewares/LwIP/Netif
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/STemWin/Config
    ../Config/: GUIConf.c LCDConf.c
  group Middlewares/STemWin/Library
    ../Middlewares/ST/STemWin/Lib/: STemWin528_CM7_OS_IAR_ot.a
  group Middlewares/STemWin/OS
    ../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../STemWin_Addons/: STM32746G_Discovery_STemWin_Addons_IAR.a
  group Middlewares/USBH_Library/Class/MSC
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/USBH_Library/Config
    ../Config/: usbh_conf.c
  group Middlewares/USBH_Library/Core
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
